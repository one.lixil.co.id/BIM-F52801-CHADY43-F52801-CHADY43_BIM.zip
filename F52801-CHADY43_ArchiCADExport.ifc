Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2021-05-11T09:58:19
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcBuildingElementProxy: Concept Round Paper Holder AS, F52801-CHADY43:Concept Round Paper Holder AS:3423
In: Level 1
Type - Classification: C1030200 (Uniformat); Material: Chrome
Type - Constraints - Default Elevation: 0 mm
Type - Data - ConnectionSize: n/a; FlowRate: n/a; InstallationType: n/a; ProductCategory: Bathroom Fittings (40); ProductGroup: Bathroom Accessories (02); ProductWeight: n/a; StyleSegment: n/a; SubCategory: Bathroom Accessories (17)
Type - Identity Data - Assembly Code: C1030200; Description: Concept Round Paper Holder AS; Keynote: N13; Manufacturer: American Standard; Model: Concept Round Paper Holder AS; OmniClass Number: 23.40.20.21.21; OmniClass Title: Toilet Paper Dispensers; Type Comments: F52801-CHADY43; Type Name: Concept Round Paper Holder AS; URL: https://www.americanstandard-apac.com/
Type - Model Properties - _AuthorizedBy: bimstore; _BimSpecGuid: 0; _BSBibleVersion: 16; _CreatedBy: https://www.bimstore.co; _CurrentRevision: 1; _DistributedBy: https://www.bimstore.co; _ObjectUserGuide: https://www.bimstore.co/products/f52801-chady43/document/object-user-guide; BIMObjectName: AmericanStandard_BathroomAccessories_Concept_(F52801-CHADY43); NBSDescription: Toilet paper dispensers; NBSNote: n/a; NBSObjectName: American Standard - Toilet paper dispensers; NBSOfficeMasterTag: n/a; NBSReference: 45-35-72/366
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; ClassificationName: Uniclass2015; ClassificationValue: Pr_40_70_22_90; CodePerformance: n/a; Color: n/a; Constituents: n/a; CreatedBy: https://www.americanstandard-apac.com/; CreatedOn: 2021-03-01T09:00:00; DocumentationCertificates: https://www.bimstore.co/products/f52801-chady43/document/product-certificates; DocumentationInstallationGuide: https://www.bimstore.co/products/f52801-chady43/document/installation-guide; DocumentationLiterature: https://www.bimstore.co/products/f52801-chady43/document/product-literature; DocumentationMaintenance: https://www.bimstore.co/products/f52801-chady43/document/maintenance-information; DocumentationTechnical: https://www.bimstore.co/products/f52801-chady43/document/technical-data-sheet; DurationUnit: Years; ExpectedLife: 0; Family Name: F52801-CHADY43; Features: n/a; Finish: n/a; Grade: n/a; ManufacturerName: American Standard; Material: n/a; ModelNumber: F52801-CHADY43; ModelReference: Concept Round Paper Holder AS; ProductionYear: 2021; ReferencedStandard: n/a; ReplacementCost: n/a; Shape: n/a; Size: n/a; TypeName: Concept Round Paper Holder AS; WarrantyDescription: n/a; WarrantyDurationLabor: 0; WarrantyDurationParts: 0; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.americanstandard-apac.com/; WarrantyGuarantorParts: https://www.americanstandard-apac.com/
Pset_BuildingElementProxyCommon - Reference: Concept Round Paper Holder AS
Pset_ManufacturerTypeInformation - ModelReference: Concept Round Paper Holder AS; Manufacturer: American Standard; ProductionYear: 2021
Constraints - Elevation: 0 mm
Dimensions - Area: 0.00743167 m2; Volume: 0.0000372149 m3
Identity Data - Mark: 1
Other - AssetIdentifier: n/a; BarCode: Please Record On Commissioning.; Family: F52801-CHADY43: Concept Round Paper Holder AS; Family and Type: F52801-CHADY43: Concept Round Paper Holder AS; InstallationDate: Please Record On Commissioning.; SerialNumber: Please Record On Commissioning.; Type: F52801-CHADY43: Concept Round Paper Holder AS; Type Id: F52801-CHADY43: Concept Round Paper Holder AS; WarrantyStartDate: Please Record On Commissioning.
Phasing - Phase Created: New Construction
AC_Pset_RenovationAndPhasing - Renovation Status: New
